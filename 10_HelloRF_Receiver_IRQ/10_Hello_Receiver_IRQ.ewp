# IAR project 10_Hello_Receiver_IRQ.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8S103F3P STM8S103F3P
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: 10_Hello_Receiver_IRQ.srec
  ILINK.IlinkOutputFile: 10_Hello_Receiver_IRQ.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  ICCSTM8.CCDefines: NDEBUG
  group (top)
    ./: ClockUartLed.c ClockUartLed.h commonTypes.h main.c nRF_Configuration.h nRF_IRQ.c nRF_IRQ.h nRF_LowLevel.c nRF_LowLevel.h nRF_Modes.c nRF_Modes.h nRF_RegText.c nRF_RegText.h nRF_SPI.c nRF_SPI.h nRF_Tx.c nRF_Tx.h
