<?xml version="1.0" encoding="iso-8859-1"?>

<project>
  <fileVersion>2</fileVersion>
  <configuration>
    <name>Debug</name>
    <toolchain>
      <name>STM8</name>
    </toolchain>
    <debug>1</debug>
  </configuration>
  <configuration>
    <name>Release</name>
    <toolchain>
      <name>STM8</name>
    </toolchain>
    <debug>0</debug>
  </configuration>
  <file>
    <name>$PROJ_DIR$\ClockUartLed.c</name>
  </file>
  <file>
    <name>$PROJ_DIR$\ClockUartLed.h</name>
  </file>
  <file>
    <name>$PROJ_DIR$\commonTypes.h</name>
  </file>
  <file>
    <name>$PROJ_DIR$\main.c</name>
  </file>
  <file>
    <name>$PROJ_DIR$\nRF_LowLevel.c</name>
  </file>
  <file>
    <name>$PROJ_DIR$\nRF_LowLevel.h</name>
  </file>
  <file>
    <name>$PROJ_DIR$\nRF_Modes.c</name>
  </file>
  <file>
    <name>$PROJ_DIR$\nRF_Modes.h</name>
  </file>
  <file>
    <name>$PROJ_DIR$\nRF_RegText.c</name>
  </file>
  <file>
    <name>$PROJ_DIR$\nRF_RegText.h</name>
  </file>
  <file>
    <name>$PROJ_DIR$\nRF_SPI.c</name>
  </file>
  <file>
    <name>$PROJ_DIR$\nRF_SPI.h</name>
  </file>
  <file>
    <name>$PROJ_DIR$\nRF_Tx.c</name>
  </file>
  <file>
    <name>$PROJ_DIR$\nRF_Tx.h</name>
  </file>
</project>


